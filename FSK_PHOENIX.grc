options:
  parameters:
    author: C3
    copyright: Cubesat Team PoliTO
    description: FSK packet mod and demod flowgraph with HDLC framing and CRC32 (+CRC16). Blocks disabled are for debugging.
    generate_options: qt_gui
    id: FSK_HDLC_TRX
    output_language: python
    title: FSK TRX
  states: {}

blocks:
- name: FREQ
  id: variable
  parameters:
    value: '0'
  states: {}
- name: TED
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: TED
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.35'
  states: {state: disabled}
- name: TXRX
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0,0
    initPressed: 'False'
    label: Press red for TX
    pressBackgroundColor: red
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 2*(bitrate+fsk_deviation_hz)
  states: {}
- name: bitrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decim_rx
  id: variable
  parameters:
    value: '5'
  states: {}
- name: filesize
  id: variable
  parameters:
    value: '256'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: loop
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: loop
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.7'
  states: {state: disabled}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: bandwidth/1.4
    gain: '1.0'
    samp_rate: samp_rate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: mark
  id: variable
  parameters:
    value: fsk_deviation_hz
  states: {}
- name: maxVCO
  id: variable
  parameters:
    value: fsk_deviation_hz
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: samp_rate/decim_rx
  states: {}
- name: space
  id: variable
  parameters:
    value: '-fsk_deviation_hz'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate_rx)/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: (space) / (maxVCO)
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-0.075'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/giorgio/output.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/giorgio/input.txt
    repeat: 'True'
    type: byte
    vlen: filesize
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.make_dict()
    period: '2000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (mark - space) / (maxVCO)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*(1/9600))
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: TXRX
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: filesize
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: received_pkts
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: maxVCO
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: loop
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: (samp_rate_rx)/bitrate
    ted_gain: TED
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: FREQ
    decim: decim_rx
    samp_rate: samp_rate
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    samp_per_symbol: int((samp_rate_rx)/bitrate)
    size: 1024*10
    srate: samp_rate_rx
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '16384'
    gui_hint: 1,1
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 1,0
    name: '"Symbol Syncronizator Error"'
    size: '1024'
    srate: samp_rate_rx
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '16384'
    gui_hint: 0,1
    name: '"RX"'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'False'
    max_length: '500'
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '32'
    preamble_bytes: '32'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_select
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkts
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: pkt_rx
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: RX
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: RX_post_sync
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: to_select
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pkts
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: pkt_rx
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: RX_post_sync
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_c_0, '0']
- [blocks_add_const_vxx_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_file_source_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_message_strobe_0, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_throttle2_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', virtual_sink_3, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_throttle2_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_uchar_to_float_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vco_c_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_2, '0']
- [digital_crc32_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tag_debug_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_add_const_vxx_1, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_4_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_4, '0']
- [pdu_pdu_to_tagged_stream_0, '0', virtual_sink_1, '0']
- [pdu_pdu_to_tagged_stream_1, '0', digital_crc32_bb_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_hdlc_framer_0, in]
- [satellites_hdlc_deframer_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [satellites_hdlc_framer_0, out, blocks_message_strobe_0, set_msg]
- [virtual_source_0, '0', blocks_selector_0, '0']
- [virtual_source_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_1, '0', blocks_repeat_0, '0']
- [virtual_source_2, '0', satellites_hdlc_deframer_0, '0']
- [virtual_source_3, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_3, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_4, '0', qtgui_eye_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
